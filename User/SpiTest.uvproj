# Keil uVision project SpiTest.uvproj, settings and files
target SpiTest (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SpiTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hardware;..\Peripheral;..\Sys;..\User
  group User
    ./: main.c
  group Hardware
    ../Hardware/: GPIO.c SPI.c USART.C
  group Peripheral
    ../Peripheral/: MCP3302.c
  group Sys
    ../Sys/: delay.c timer.c
